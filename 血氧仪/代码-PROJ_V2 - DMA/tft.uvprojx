# Keil uVision project tft.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CW32L031C8 WHXY
  pack: WHXY.CW32L031_DFP.1.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tft +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER;.\Libraries\inc;.\Libraries\src;.\USER\inc;.\USER\src;.\TFT;.\Debug;.\Startup;.\ADC;.\FFT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./USER/: interrupts_cw32l031.c interrupts_cw32l031.h main.c main.h
  group Libraries
    ./Libraries/src/: cw32l031_adc.c cw32l031_atim.c cw32l031_awt.c cw32l031_btim.c cw32l031_crc.c cw32l031_debug.c cw32l031_digitalsign.c cw32l031_dma.c cw32l031_flash.c cw32l031_gpio.c cw32l031_gtim.c cw32l031_i2c.c cw32l031_iwdt.c cw32l031_lvd.c cw32l031_pwr.c cw32l031_ram.c cw32l031_rcc.c cw32l031_rtc.c cw32l031_spi.c cw32l031_systick.c cw32l031_uart.c cw32l031_vc.c cw32l031_wwdt.c system_cw32l031.c
  group TFT
    ./TFT/: LCD.c LCD_INIT.c LCD_FONT.h pic.h
  group Startup
    ./Startup/: startup_cw32l031.s
    ./Libraries/inc/: cw32l031.h
  group FFT
    ./FFT/: FFT.c FFT.h
software components: CMSIS:CORE 5.5.0
